# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MH1902, USE_STDPERIPH_DRIVER, USE_HAL_DRIVER, RT_USING_ARM_LIBC, __RTTHREAD__
  c misc: --diag_suppress=550,3135
  c include: applications;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\drivers;libraries\drivers\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\ramfs;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;libraries\mhscpu\CMSIS\Include;libraries\mhscpu\Device\MegaHunt\mhscpu\Include;libraries\mhscpu\MHSCPU_Driver\inc;libraries\mhscpu\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc;libraries\mhscpu\SCPU_USB_Lib\SCPU_USB_Device_Library\Core\inc;packages\mbedtls-v2.7.10.1\mbedtls\include;packages\mbedtls-v2.7.10.1\ports\inc;packages\netutils-v1.3.1\ntp;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;packages\ulog_file-v1.0.0;.;rt-thread\components\utilities\ulog;packages\webclient-v2.1.2\inc;packages\wiznet-latest\inc;packages\wiznet-latest\ioLibrary;packages\wiznet-latest\ioLibrary\Ethernet;packages\wiznet-latest\ioLibrary\Internet
  memory RVCT4: ROM 0x1001000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    board/ports/: spi_flash_init.c fs_init.c w5500_init.c
    libraries/mhscpu/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
    libraries/drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_common.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/filesystems/ramfs/: dfs_ramfs.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c unistd.c
  group Libraries
    libraries/mhscpu/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
    libraries/mhscpu/MHSCPU_Driver/src/: mhscpu_dma.c mhscpu_cache.c mhscpu_crc.c mhscpu_bpk.c mhscpu_exti.c mhscpu_it.c mhscpu_otp.c mhscpu_sysctrl.c misc.c mhscpu_gpio.c mhscpu_uart.c mhscpu_i2c.c mhscpu_spi.c mhscpu_rtc.c
  group mbedtls
    packages/mbedtls-v2.7.10.1/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    packages/mbedtls-v2.7.10.1/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
    packages/mbedtls-v2.7.10.1/samples/: tls_app_test.c
  group NetUtils
    packages/netutils-v1.3.1/ntp/: ntp.c
  group paho-mqtt
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
    packages/pahomqtt-v1.1.0/samples/: mqtt_sample.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group ulog_file
    packages/ulog_file-v1.0.0/: ulog_file_be.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
    packages/webclient-v2.1.2/samples/: webclient_get_sample.c webclient_post_sample.c
  group WIZnet
    packages/wiznet-latest/src/: wiz_af_inet.c wiz_device.c wiz_socket.c wiz.c wiz_ping.c
    packages/wiznet-latest/ioLibrary/Ethernet/: wizchip_conf.c wizchip_socket.c
    packages/wiznet-latest/ioLibrary/Internet/DNS/: wizchip_dns.c
    packages/wiznet-latest/ioLibrary/Internet/DHCP/: wizchip_dhcp.c
    packages/wiznet-latest/ioLibrary/Ethernet/W5500/: w5500.c
