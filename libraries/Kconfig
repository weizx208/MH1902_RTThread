## libraries/Kconfig
```kconfig
config SOC_FAMILY_SC300
    bool

config SOC_SERIES_MH1902
    bool
    select ARCH_ARM_CORTEX_M3
    select SOC_FAMILY_SC300
```
